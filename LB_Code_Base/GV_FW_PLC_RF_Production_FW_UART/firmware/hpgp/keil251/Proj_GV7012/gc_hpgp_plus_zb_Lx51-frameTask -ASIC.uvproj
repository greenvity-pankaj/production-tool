# Keil uVision project gc_hpgp_plus_zb_Lx51-frameTask -ASIC.uvproj, settings and files
target GV7011_Generic (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,HPGP_DEBUG,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HYBRII_ETH,HPGP_MAC_SAP,NMA,HYBRII_SPI,NEW_SYNC,UM,HYBRII_B,Hybrii_B,HW_SPI_TX_CRC,HW_SPI_RX_CRC,B_ASICPLC,FREQ_DETECT,SW_RECOVERY,DEBUG_DATAPATH_,HYBRII_ASIC_A2,HYBRII_802154,BB_CAL,BB_GAIN_TABLE,B2,HYBRII_B_AFE,_BC_SECURE_TEST_,BCN_ERR,KEEP_ALIVE,MCCO
  c misc: NOAREGS
  c include: ..\..\..\common\datapath;..\..\..\common\include;..\..\..\hal;..\..\src\crypto;..\..\src\ctrl;..\..\src\hal;..\..\src\link;..\..\src\mux;..\..\src\nma;..\..\src\route;..\..\src\test;..\..\..\project\hal\src;..\..\..\zigbee;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\common;..\..\..\hpgp;..\..\src;..\..\..\HybriiB_configuration_rw\src;..\..\..\..\components\drivers\flash\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\components\nma\hpgp\inc;..\..\..\..\components\osal\inc;..\..\..\..\components\drivers\gpio\inc;..\..\..\..\components\nma;..\..\..\zigbee;..\..\..\..\components\nma\ieee802154\inc;..\..\..\..\components\ieee802154\inc;..\..\..\..\components\utilities;..\..\..\..\components\drivers\uart\inc;..\..\..\..\components\utilities\debug\inc
  link misc: REMOVEUNUSED
  group startup
    ../../../../OS/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY.A51
    ../../../project/hal/src/: clear_char.A51
  group common
    ../../../common/: stm.c interrupt.c
    ../../../hal/: gv701x_uartdriver.c
  group Bank 0
    ../../../hal/: hal_hpgpRx.c hal_common.c
    ../../src/: green.c hpgpctrl.c
    ../../../common/: list.c uart.c dmm.c event.c
    ../../src/crypto/: aes.c
    ../../src/link/: akm.c hom.c
    ../../../../components/utilities/debug/src/: fm.c
  group Bank 1
    ../../src/hal/: hal.c
    ../../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
    ../../../common/: ui_utils.c sys_common.c
    ../../src/mux/: muxl.c
    ../../src/crypto/: crc32.c
    ../../../project/hal/src/: hhal_led.c
    ../../../hal/: hal_eth.c hal_hpgp.c hal_spi.c
    ../../src/route/: hpgp_route.c
  group Bank 2
    ../../src/link/: psm.c nam.c
    ../../../hal/: hal_hpgpTx.c
  group Bank 3
    ../../../common/: utils.c ism.c
    ../../src/link/: crm.c linkl.c nsm_cco.c
  group Bank 4
    ../../../project/hal/src/: hal_hpgp_reset.c
    ../../../app_support/: app_sup_layer.c
    ../../../common/datapath/: FrameTask.c
    ../../src/ctrl/: ctrll.c
    ../../src/link/: nsm_sta.c
  group Bank 5
    ../../../zigbee/: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c mac_mcps_data.c mac_pib.c mac_security.c
  group Bank 6
    ../../../common/datapath/: datapath.c
    ../../../zigbee/: qmm.c bmm.c mac_start.c mac_scan.c mac_orphan.c mac_associate.c mac_beacon.c mac_disassociate.c mac_host_cb.c mac_misc.c mac_poll.c mac_rx_enable.c mac_sync.c
  group Bank 7
    ../../src/test/: htm.c
    ../../src/nma/: nma.c
    ../../../zigbee/: mac_diag.c
    ../../../common/: gv701x_cfg.c gv701x_flash.c
    ../../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
