# Keil uVision project hybrii_prameter_rw.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: hybrii_prameter_rw +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src
  group Source Group 1
    ../src/: main.c uart.c STARTUP.A51 sys_config_data_utils.c
