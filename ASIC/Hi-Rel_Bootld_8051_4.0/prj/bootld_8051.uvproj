# Keil uVision project bootld_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: bootld_8051_2_0_fpga +hex
  c flags: Optimize=8
  c define: IDATA_OPT,FEATURE_CHIPERASE_
  c include: ..\src
  group Source Group 1
    ../src/: main.c uart.c STARTUP.A51 cmem_ctrl.c hex_file_hdl.c spiflash.c spiflash_drv.c
