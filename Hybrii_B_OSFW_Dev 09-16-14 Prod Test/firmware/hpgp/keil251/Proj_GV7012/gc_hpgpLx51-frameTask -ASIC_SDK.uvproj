# Keil uVision project gc_hpgpLx51-frameTask -ASIC_SDK.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,HPGP_DEBUG,PLC_SW_CSMA,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HYBRII_ETH, HPGP_MAC_SAP,NMA, HYBRII_SPI,DUP_CP,NEW_SYNC,UM,HYBRII_B,Hybrii_B,HW_SPI_TX_CRC,HW_SPI_RX_CRC,AUTH_AES,DEBUG_DATAPATH,UART_RAW,PLC_TEST,B_ASICPLC,UART_HOST_INTF,NO_HOST,FREQ_DETECT,LG_UART_CONFIG
  c misc: NOAREGS
  c include: ..\..\..\common\datapath;..\..\..\common\include;..\..\..\hal;..\..\src\crypto;..\..\src\ctrl;..\..\src\hal;..\..\src\link;..\..\src\mux;..\..\src\nma;..\..\src\route;..\..\src\sap;..\..\src\test;..\..\..\project\hal\src;..\..\..\zigbee;..\..\..\..\components\aps\inc;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\..\sampleapp\src;..\..\..\..\sampleapp\inc;..\..\..\common;..\..\..\hpgp;..\..\src;..\..\..\..\components\hpgp\inc;..\..\..\app_support;..\..\..\HybriiB_configuration_rw\src
  link misc: REMOVEUNUSED
  group startup
    ../../../common/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY.A51
    ../../../project/hal/src/: clear_char.A51
  group common
    ../../src/: green.c
    ../../../hal/: uart_driver.c
    ../../../common/: interrupt.c
  group Bank 0
    ../../../hal/: hal_common.c hal_hpgpRx.c
    ../../../common/: list.c fm.c uart.c dmm.c event.c
    ../../src/: hpgpctrl.c
  group Bank 1
    ../../../common/: stm.c sys_common.c
    ../../../project/hal/src/: hhal_led.c
    ../../../hal/: hal_eth.c hal_hpgp.c hal_spi.c
    ../../src/route/: hpgp_route.c
  group Bank 2
    ../../../hal/: hal_hpgpTx.c
    ../../../common/datapath/: datapath.c FrameTask.c
  group Bank 3
    ../../../common/: ism.c
    ../../src/link/: crm.c linkl.c nsm_cco.c
  group Bank 4
    ../../src/ctrl/: ctrll.c
    ../../src/link/: nsm_sta.c
    ../../src/nma/: nma.c
    ../../src/mux/: muxl.c
  group Bank 5
    ../../src/link/: nam.c
    ../../src/test/: htm.c
    ../../src/hal/: hal.c
    ../../../common/: ui_utils.c
    ../../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
  group Bank 6
    ../../../common/: utils.c gv701x_event.c
    ../../src/sap/: hpgp_mac_intf.c mac_intf_common.c
    ../../src/crypto/: aes.c crc32.c
    ../../src/link/: hom.c akm.c psm.c
    ../../../project/hal/src/: hal_hpgp_reset.c
    ../../../../sampleapp/src/: uartapp.c gv701x_task.c gv701x_driver.c
    ../../../app_support/: app_sup_layer.c
