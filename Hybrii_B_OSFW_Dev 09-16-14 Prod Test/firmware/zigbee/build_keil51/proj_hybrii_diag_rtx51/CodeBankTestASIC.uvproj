# Keil uVision project CodeBankTestASIC.uvproj, settings and files
target Target 1 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: CodeBankTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: P8051, _CRC_VERIFY_,  _VERIFY_PAYLOAD_,  _BC_SECURE_TEST_, HYBRII_ASIC, HYBRII_ZIGBEE, HYBRII_SPI, HPGP_HAL_TEST, RTX51_TINY_OS, SPI_DIAG, HYBRII_ASIC_A2, HYBRII_B, SPI_ECHO_, BB_CAL, BB_GAIN_TABLE, inline, HYBRII_B_AFE
  c include: ..\..\..\zigbee;..\..\..\common;..\..\..\hal;..\..\..\hpgp\src;..\..\..\project\hal\src;..\..\..\hpgp\src\hal;..\..\..\hpgp\src\nma;..\..\..\common\datapath;..\..\..\hpgp\src\sap;..\..\..\hpgp\src\link;..\..\..\..\components\hpgp\inc;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\..\components\aps\inc
  group startup
    ../../../common/: L51_PALM_BANK.A51 STARTUP.A51 CONF_TNY.A51
  group common
    ../../../common/: stm.c list.c ism.c uart.c fm.c utils.c ui_utils.c sys_common.c interrupt.c
    ../../../hal/: hal_common.c
    ../../: bmm.c qmm.c
  group bank 0
    ../../: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c
  group bank 1
    ../../: mac_mcps_data.c mac_associate.c mac_beacon.c mac_security.c mac_orphan.c mac_start.c mac_pib.c mac_scan.c mac_disassociate.c
  group bank 2
    ../../: mac_rx_enable.c mac_poll.c mac_sync.c mac_misc.c
    ../../../common/: gv701x_cfg.c
    ../../../hal/: hal_spi.c
  group bank 3
    ../../: mac_host_cb.c main.c mac_diag.c
    ../../../common/datapath/: datapath.c FrameTask.c
