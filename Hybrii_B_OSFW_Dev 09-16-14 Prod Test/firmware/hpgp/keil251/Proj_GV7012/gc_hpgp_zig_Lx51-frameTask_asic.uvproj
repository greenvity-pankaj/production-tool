# Keil uVision project gc_hpgp_zig_Lx51-frameTask_asic.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=9
  c define: inline,P8051,HPGP_HAL,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST, RTX51_TINY_OS, HYBRII_ASIC, PLC_SW_SYNC,HPGP_MAC_SAP,NMA, AUTH_AES, HYBRII_SPI,NEW_SYNC,UM,HYBRII_B,HYBRII_ZIGBEE,HYBRII_ASIC_A2,BB_CAL,BB_GAIN_TABLE,UART_RAW,B_ASICPLC,FREQ_DETECT
  c misc: NOAREGS
  c include: ..\..\..\common\datapath;..\..\..\common\include;..\..\..\hal;..\..\src\crypto;..\..\src\ctrl;..\..\src\hal;..\..\src\link;..\..\src\mux;..\..\src\nma;..\..\src\route;..\..\src\sap;..\..\src\test;..\..\..\project\hal\src;..\..\..\zigbee;..\..\..\..\components\aps\inc;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\..\sampleapp\src;..\..\..\..\sampleapp\inc;..\..\..\common;..\..\..\hpgp;..\..\src;..\..\..\..\components\hpgp\inc;..\..\..\app_support;..\..\..\HybriiB_configuration_rw\src
  link misc: REMOVEUNUSED
  group startup
    ../../../common/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY.A51
    ../../../project/hal/src/: clear_char.A51
  group common
    ../../src/: green.c
    ../../../common/: interrupt.c
    ../../../hal/: uart_driver.c
  group Bank 0
    ../../../project/hal/src/: hhal_led.c
    ../../../hal/: hal_spi.c hal_hpgpTx.c hal_hpgp.c hal_eth.c hal_hpgpRx.c
    ../../src/: hpgpctrl.c
    ../../../common/: list.c fm.c uart.c dmm.c
  group Bank 1
    ../../../common/: ism.c sys_common.c stm.c
    ../../../hal/: hal_common.c
    ../../src/link/: crm.c hom.c akm.c
    ../../src/hal/: hal.c
    ../../src/route/: hpgp_route.c
  group Bank 2
    ../../../common/: ui_utils.c
    ../../src/crypto/: aes.c crc32.c
    ../../src/sap/: mac_intf_common.c hpgp_mac_intf.c
    ../../src/test/: htm.c
    ../../../common/datapath/: datapath.c FrameTask.c
    ../../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
  group Bank 3
    ../../../common/: utils.c
    ../../src/link/: nam.c nsm_cco.c
  group Bank 4
    ../../../common/: event.c
    ../../src/ctrl/: ctrll.c
    ../../src/link/: nsm_sta.c
    ../../src/nma/: nma.c
    ../../src/mux/: muxl.c
  group Bank 5
    ../../../zigbee/: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c mac_mcps_data.c mac_pib.c mac_security.c
  group Bank 6
    ../../src/link/: linkl.c
    ../../../zigbee/: mac_beacon.c mac_associate.c mac_disassociate.c mac_host_cb.c mac_misc.c mac_poll.c mac_rx_enable.c mac_sync.c
  group Bank 7
    ../../../common/: gv701x_cfg.c
    ../../../zigbee/: bmm.c qmm.c mac_orphan.c mac_scan.c mac_start.c mac_diag.c zb_usr_mac_sap.c
