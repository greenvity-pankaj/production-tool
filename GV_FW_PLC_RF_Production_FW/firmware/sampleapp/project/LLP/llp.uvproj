# Keil uVision project llp.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: llp +hex (library)
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,HPGP_DEBUG,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HPGP_MAC_SAP,NMA,HYBRII_SPI,NEW_SYNC,AUTH_AES,UM,HYBRII_B,Hybrii_B,HW_SPI_TX_CRC,HW_SPI_RX_CRC,B_ASICPLC,HYBRII_ASIC_A2,BB_CAL,BB_GAIN_TABLE,B2,FREQ_DETECT,HYBRII_B_AFE,_BC_SECURE_TEST_,DEBUG_DATAPATH,FREQ_DETECT,UART_RAW,UART_HOST_INTF,UART_GPIO_INTERRUPT,SW_RECOVERY,NO_HOST,BCN_ERR,ROUTE_APP,REGISTER_APP,LLP_APP
  c misc: NOAREGS
  c include: ..\..\..\firmware\common\datapath;..\..\..\firmware\common\include;..\..\..\firmware\hal;..\..\..\firmware\hpgp\src\crypto;..\..\..\firmware\hpgp\src\ctrl;..\..\..\firmware\hpgp\src\hal;..\..\..\firmware\hpgp\src\link;..\..\..\firmware\hpgp\src\mux;..\..\..\firmware\hpgp\src\nma;..\..\..\firmware\hpgp\src\route;..\..\..\firmware\hpgp\src\test;..\..\..\firmware\project\hal\src;..\..\..\firmware\zigbee;..\..\..\components\aps\inc;..\..\..\components\utilities\datatype\inc;..\..\..\components\utilities\event\inc;..\..\..\components\utilities\linklist\inc;..\..\..\components\utilities\timer\inc;..\..\..\components\hpgp\inc;..\src;..\inc;..\..\..\firmware\common;..\..\..\firmware\hpgp;..\..\..\firmware\hpgp\src;..\..\..\firmware\app_support;..\..\..\firmware\HybriiB_configuration_rw\src;..\..\..\components\drivers\gpio\inc;..\..\..\components\drivers\hpgp\inc;..\..\..\components\drivers\nwk\inc;..\..\..\components\drivers\ieee802154\inc;..\..\..\components;..\..\..\components\osal\inc;..\..\..\components\nma\hpgp\inc;..\..\..\components\nma\ieee802154\inc;..\..\..\components\nma;..\..\..\components\utilities\event\inc;..\..\..\components\hpgp\inc;..\..\..\components\drivers\flash\inc;..\..\..\components\ieee802154\inc;..\..\..\components\drivers\uart\inc;..\..\..\components\utilities;..\..\..\sampleapp\inc;..\..\..\sampleapp\src
  link misc: REMOVEUNUSED
  group startup
    ../../../OS/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY_wo_timer_int.A51
    ../../../firmware/project/hal/src/: clear_char.A51
  group LLP
    ../../../sampleapp/src/: route.c register.c llpapp.c
