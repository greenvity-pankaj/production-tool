# Keil uVision project CodeBankTestAsic-ZP-B2 - SysConfig.uvproj, settings and files
target Target 1 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ZP B2 Fcfg +hex
  c flags: Optimize=9
  c define: P8051, _CRC_VERIFY_,  HYBRII_802154, HYBRII_ASIC, HYBRII_SPI, HPGP_HAL_TEST, RTX51_TINY_OS, SPI_DIAG, HYBRII_ASIC_A2, HYBRII_HPGP, HYBRII_ETH, PLC_SW_SYNC, inline, BB_GAIN_TABLE,  BB_CAL, HYBRII_B, HYBRII_B_AFE, B_ASICPLC, FT, B2,  Flash_Config,MPER, ZBMAC_DIAG, MAC_802154_TASK, HAL_802154_TASK
  c include: ..\..\..\zigbee;..\..\..\common;..\..\..\hal;..\..\..\hpgp\src;..\..\..\project\hal\src;..\..\..\hpgp\src\hal;..\..\..\hpgp\src\nma;..\..\..\common\datapath;..\..\..\hpgp\src\link;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\..\components\drivers\gpio\inc;..\..\..\..\components\osal\inc;..\..\..\HybriiB_configuration_rw\src;..\..\..\..\components\ieee802154\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\components\nma\hpgp\inc;..\..\..\..\components\nma\ieee802154\inc;..\..\..\..\components\nma;..\..\..\..\components\drivers\flash\inc;..\..\..\..\components\utilities;..\..\..\..\components\utilities\debug\inc
  group startup
    ../../../project/hal/src/: clear_char.A51
    ../../../../OS/: CONF_TNY.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../../common/: stm.c list.c interrupt.c ism.c
  group bank 0
    ../../../hal/: hal_hpgpRx.c hal_common.c
    ../../../project/hal/src/: ehal_tst.c chal_tst.c ihal_ui.c ihal_tst.c hal_main.C
    ../../../common/: utils.c
    ../../../../components/utilities/debug/src/: fm.c
  group bank 1
    ../../../hal/: hal_hpgp.c hal_eth.c
    ../../../project/hal/src/: hhal_tst.c hhal_led.c
    ../../../common/: sys_common.c
  group bank 2
    ../../../hal/: hal_hpgpTx.c hal_spi.c
    ../../../common/datapath/: datapath.c FrameTask.c
  group bank 3
    ../../: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c mac_security.c
  group bank 4
    ../../: mac_associate.c mac_beacon.c mac_mcps_data.c mac_orphan.c mac_start.c mac_pib.c mac_scan.c mac_disassociate.c mac_poll.c mac_sync.c mac_misc.c mac_rx_enable.c bmm.c qmm.c mac_host_cb.c
    ../../../common/: gv701x_cfg.c
  group bank 5
    ../../: mac_diag.c
    ../../../common/: ui_utils.c gv701x_flash.c
    ../../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
    ../../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
    ../../../hpgp/src/crypto/: crc32.c
    ../../../project/hal/src/: hal_prod_tst.c hal_rf_prod_test.c prod_test_correct_endieness.c
