# Keil uVision project gc_hpgpLx51-frameTask-ASIC.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=9
  c define: P8051, HYBRII_8051, HYBRII_HPGP, HYBRII_ASIC, PLC_SW_SYNC=1, inline, HPGP_HAL_TEST,RTX51_TINY_OS,_TIMER_INTERRUPT_,SNIFFER,Hybrii_B, NEW_SYNC,_TIMER_INTERRUPT_,HYBRII_B,HW_SPI_TX_CRC,HW_SPI_RX_CRC,_CRC_VERIFY_, HYBRII_SPI,SNIFFER,HYBRII_ETH,B_ASICPLC,FREQ_DETECT,PROD_TEST
  c include: ..\..\common;..\..\project\hal\src;..\..\hpgp\src\mux;..\..\hpgp\src\link;..\..\hpgp\src\ctrl;..\..\hpgp\src\nma;..\..\hal;.\src;..\..\hpgp\src\hal;..\..\hpgp\src\sap;..\..\hpgp\src\test;..\..\hpgp\src\;..\..\common\datapath;..\..\hpgp\src\route;..\..\..\components\utilities\datatype\inc;..\..\..\components\utilities\event\inc;..\..\..\components\utilities\linklist\inc;..\..\..\components\utilities\timer\inc;..\..\app_support;..\..\..\sampleapp\src;..\..\..\sampleapp\inc;..\..\..\components\hpgp\inc;..\..\..\components\aps\inc
  group startup
    ../../common/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY.A51
    ./src/: clear_char.A51
  group common
    ../../hal/: hal_common.c
    ./src/: hal_main.C
    ../../common/: fm.c list.c utils.c ism.c
  group Bank 0
    ../../hal/: hal_hpgpRx.c
    ./src/: ehal_tst.c chal_tst.c ihal_ui.c ihal_tst.c
  group Bank 1
    ../../hal/: hal_hpgp.c
    ../../common/: sys_common.c
  group Bank 3
    ../../hal/: hal_hpgpTx.c
    ../../common/datapath/: datapath.c FrameTask.c
    ./src/: prod_test_correct_endieness.c
  group Bank 4
    ./src/: hhal_tst.c hhal_led.c hal_prod_tst.c
    ../../hal/: hal_eth.c hal_spi.c
