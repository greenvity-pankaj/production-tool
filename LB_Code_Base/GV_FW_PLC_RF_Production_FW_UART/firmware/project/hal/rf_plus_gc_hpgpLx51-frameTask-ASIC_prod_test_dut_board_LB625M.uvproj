# Keil uVision project rf_plus_gc_hpgpLx51-frameTask-ASIC_prod_test_dut_board_LB625M.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp_dut_lb +hex
  c flags: Optimize=9
  c define: P8051, HYBRII_802154, SPI_DIAG_, HYBRII_ASIC_A2, BB_GAIN_TABLE,  BB_CAL, HYBRII_B_AFE, FT, B2,ZBMAC_DIAG,HYBRII_8051, HYBRII_HPGP, HYBRII_ASIC, PLC_SW_SYNC, inline, HPGP_HAL_TEST,RTX51_TINY_OS,SNIFFER_,Hybrii_B, NEW_SYNC,HYBRII_B,HW_SPI_TX_CRC_,HW_SPI_RX_CRC_,_CRC_VERIFY_, HYBRII_SPI,HYBRII_ETH_,B_ASICPLC,FREQ_DETECT_,PROD_TEST,TYPE_DUT,TIMER_POLL,HYBRII_B,HPGP_HAL,_BC_SECURE_TEST_,SPI_LOG,Flash_Config,UART_HOST_INTF,LG_UART_CONFIG,UART_RAW,LB_6_25M_CLOCK,NO_RF_CAL
  c misc: NOAREGS
  c include: ..\..\common;.\src;..\..\hpgp\src\mux;..\..\hpgp\src\link;..\..\hpgp\src\ctrl;..\..\hpgp\src\nma;..\..\hal;..\..\hpgp\src\hal;..\..\hpgp\src\test;..\..\hpgp\src\;..\..\common\datapath;..\..\hpgp\src\route;..\..\..\components\utilities\datatype\inc;..\..\..\components\utilities\event\inc;..\..\..\components\utilities\linklist\inc;..\..\..\components\utilities\timer\inc;..\..\..\components\nma\hpgp\inc;..\..\..\components\hpgp\inc;..\..\..\components\nma;..\..\..\components\drivers\gpio\inc;..\..\..\components\drivers\flash\inc;..\..\app_support;..\..\..\components\utilities;.\src;..\..\HybriiB_configuration_rw\src;..\..\..\components\utilities\debug\inc;..\..\..\components\utilities\datatype\inc;..\..\..\components\drivers\gpio\inc;..\..\..\components\drivers\gpio\src;..\..\zigbee;.\src;..\..\HybriiB_configuration_rw\src;..\..\..\components\ieee802154\inc;..\..\..\components\hpgp\inc;..\..\..\components\nma\hpgp\inc;..\..\..\components\nma\ieee802154\inc;..\..\..\components\drivers\flash\inc;..\..\..\components\utilities;..\..\..\components\utilities\debug\inc;..\..\hpgp\src\crypto;..\..\hal;..\..\..\components\drivers\uart\inc
  link misc: REMOVEUNUSED,NOOVERLAY
  group startup
    ./src/: clear_char.A51
    ../../../OS/: CONF_TNY.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ./src/: hal_main.C
    ../../hal/: hal_common.c gv701x_uartdriver.c
    ../../common/: ism.c
  group Bank 0
    ../../hal/: hal_hpgpRx.c
    ./src/: ehal_tst.c chal_tst.c ihal_ui.c ihal_tst.c
  group Bank 1
    ../../hal/: hal_hpgp.c hal_eth.c
    ./src/: hhal_tst.c
    ../../common/: sys_common.c
  group Bank 2
    ../../common/: list.c
    ../../hal/: hal_hpgpTx.c
    ../../common/datapath/: datapath.c FrameTask.c
    ./src/: prod_test_correct_endieness.c
  group Bank 3
    ../../common/: interrupt.c utils.c stm.c
    ../../../components/utilities/debug/src/: fm.c
    ./src/: hhal_led.c hal_prod_tst.c hal_rf_prod_test.c
    ../../hal/: hal_spi.c
    ../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
    ../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
  group Bank 4
    ../../zigbee/: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c mac_security.c
  group Bank 5
    ../../zigbee/: bmm.c mac_associate.c mac_beacon.c mac_disassociate.c mac_host_cb.c mac_mcps_data.c mac_misc.c mac_orphan.c mac_pib.c mac_poll.c mac_rx_enable.c mac_scan.c mac_start.c mac_sync.c qmm.c
    ../../common/: gv701x_cfg.c
  group Bank 6
    ../../zigbee/: mac_diag.c
    ../../common/: ui_utils.c gv701x_flash.c
    ../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
    ../../hpgp/src/crypto/: crc32.c
