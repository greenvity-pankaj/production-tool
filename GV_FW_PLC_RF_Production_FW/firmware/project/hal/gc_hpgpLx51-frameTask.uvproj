# Keil uVision project gc_hpgpLx51-frameTask.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=9
  c define: P8051, HYBRII_8051, HYBRII_HPGP, HYBRII_ASIC, PLC_SW_SYNC=1, inline, HPGP_HAL_TEST,RTX51_TINY_OS,_TIMER_INTERRUPT_,SNIFFER,Hybrii_B, NEW_SYNC,_TIMER_INTERRUPT_,HYBRII_B,GPIO_FPGA,HW_SPI_TX_CRC,HW_SPI_RX_CRC,_CRC_VERIFY_, HYBRII_SPI,SNIFFER,HYBRII_ETH,DEBUG_DATAPATH,DUP_CP
  c include: ..\..\common;.\src;..\..\hpgp\src\mux;..\..\hpgp\src\link;..\..\hpgp\src\ctrl;..\..\hpgp\src\nma;..\..\hal;..\..\hpgp\src\hal;..\..\hpgp\src\test;..\..\hpgp\src\;..\..\common\datapath;..\..\hpgp\src\route;..\..\..\components\utilities\datatype\inc;..\..\..\components\utilities\event\inc;..\..\..\components\utilities\linklist\inc;..\..\..\components\utilities\timer\inc;..\..\..\components\nma\hpgp\inc;..\..\..\components\hpgp\inc;..\..\..\components\nma;..\..\..\components\drivers\gpio\inc;..\..\..\components\drivers\flash\inc;..\..\app_support;..\..\..\components\utilities;.\src;..\..\HybriiB_configuration_rw\src
  group startup
    ./src/: clear_char.A51
    ../../../OS/: CONF_TNY.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../common/: ism.c
    ../../hal/: hal_common.c
    ./src/: hal_main.C
  group Bank 0
    ../../common/: utils.c list.c fm.c
    ../../hal/: hal_hpgpRx.c
    ./src/: ehal_tst.c chal_tst.c ihal_ui.c ihal_tst.c
  group Bank 1
    ../../hal/: hal_hpgp.c hal_eth.c
    ./src/: hhal_tst.c
    ../../common/: sys_common.c
  group Bank 3
    ../../hal/: hal_hpgpTx.c
    ../../common/datapath/: datapath.c FrameTask.c
  group Bank 4
    ./src/: hhal_led.c
    ../../hal/: hal_spi.c
    ../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
