# Keil uVision project Bridge_SmartLight_HQ.uvproj, settings and files
target Bridge_SmartLight_HQ (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: bridge_smartlight_HQ +hex
  c flags: Optimize=9
  c define: inline,P8051,C51,RTX51_TINY_OS,HPGP_DRIVER_APP,LRWPAN_DRIVER_APP,NWKSTARTUP_APP,ROUTE_APP,RTOPO_APP,REGISTER_APP,LLP_APP,BRIDGE,DEVICEINTF_APP,SMARTLIGHT_APP,LED_SMART_LIGHT,HQ_LINK_TEST
  c misc: NOAREGS
  c include: ..\..\components\utilities\datatype\inc;..\..\components\utilities\event\inc;..\..\components\utilities\linklist\inc;..\..\components\utilities\timer\inc;..\..\components\hpgp\inc;..\..\components\drivers\gpio\inc;..\..\components\drivers\hpgp\inc;..\..\components\drivers\nwk\inc;..\..\components\drivers\ieee802154\inc;..\..\components;..\..\components\osal\inc;..\..\components\nma\hpgp\inc;..\..\components\nma\ieee802154\inc;..\..\components\nma;..\..\components\utilities\event\inc;..\..\components\hpgp\inc;..\..\components\drivers\flash\inc;..\..\components\ieee802154\inc;..\..\components\drivers\uart\inc;..\..\components\utilities;..\..\components\drivers\hpgp\inc;..\..\components\drivers\ieee802154\inc;..\..\components\drivers\nwk\inc;..\..\components\utilities\debug\inc;..\inc;..\..\components\drivers\i2c\inc;..\..\components\drivers\gvspi\inc
  link misc: REMOVEUNUSED
  group startup
    ../../OS/: CONF_TNY_wo_timer_int.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../firmware-lib/: fwLIBcommon.LIB
  group Bank 0
    ../../firmware-lib/: fwLIB0.LIB
    ../src/: smartlightapp.c
    ../../components/drivers/gvspi/src/: gv701x_gvspi.c
    ../../components/drivers/i2c/src/: gv701x_i2c.c
  group Bank 1
    ../../firmware-lib/: fwLIB1.LIB
  group Bank 2
    ../../components/drivers/gpio/src/: gv701x_gpiodriver.c
    ../../firmware-lib/: fwLIB2.LIB
    ../src/: deviceintfapp.c
    ../../components/drivers/nwk/src/: gv701x_nwkstartup.c
    ../../app-lib/: hybriimeshLIB2_HQ.LIB
  group Bank 3
    ../../firmware-lib/: fwLIB3.LIB
  group Bank 4
    ../../firmware-lib/: fwLIB4.LIB
  group Bank 5
    ../../firmware-lib/: fwLIB5.LIB
  group Bank 6
    ../../components/osal/src/: gv701x_osal.c
    ../../firmware-lib/: fwLIB6.LIB
  group Bank 7
    ../../components/drivers/hpgp/src/: gv701x_hpgpdriver.c
    ../../components/drivers/ieee802154/src/: gv701x_lrwpandriver.c
    ../../app-lib/: hybriimeshLIB7_HQ.LIB
