# Keil uVision project CodeBankTestAsicLedDemo.uvproj, settings and files
target Target 1 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: CodeBankTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: HYBRII_8051, P8051, _CRC_VERIFY_,  _VERIFY_PAYLOAD_,  _BC_SECURE_TEST_, HYBRII_ASIC, HYBRII_ZIGBEE, HYBRII_SPI, HPGP_HAL_TEST, RTX51_TINY_OS, SPI_DIAG, _LED_DEMO_
  c include: ..\..\..\zigbee;..\..\..\common;..\..\..\hal;..\..\..\hpgp\src;..\..\..\project\hal\src;..\..\..\hpgp\src\hal;..\..\..\hpgp\src\nma;..\..\..\common\datapath
  group startup
    ../../../common/: L51_PALM_BANK.A51 STARTUP.A51 CONF_TNY.A51
  group common
    ../../../common/: stm.c list.c ism.c uart.c fm.c utils.c ui_utils.c sys_common.c
    ../../../hal/: hal_common.c
    ../../: bmm.c qmm.c
  group bank 0
    ../../: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c mac_host_cb.c
  group bank 1
    ../../: mac_mcps_data.c mac_associate.c mac_beacon.c mac_security.c mac_orphan.c mac_start.c mac_pib.c mac_scan.c mac_disassociate.c
  group bank 2
    ../../../hal/: hal_spi.c
    ../../../common/: gv701x_cfg.c
    ../../: mac_poll.c mac_sync.c mac_misc.c
  group bank 3
    ../../../project/hal/src/: led_board.c
    ../../: mac_diag.c main.c
