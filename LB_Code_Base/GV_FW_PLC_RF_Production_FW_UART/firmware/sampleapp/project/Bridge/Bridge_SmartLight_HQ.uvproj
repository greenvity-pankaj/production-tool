# Keil uVision project Bridge_SmartLight_HQ.uvproj, settings and files
target Bridge_SmartLight (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: bridge_smartlight_HQ +hex
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,HPGP_DEBUG,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HPGP_MAC_SAP,NMA,NEW_SYNC,UM,HYBRII_B,Hybrii_B,HW_SPI_TX_CRC,HW_SPI_RX_CRC,B_ASICPLC,HYBRII_ASIC_A2,BB_CAL,_CRC_VERIFY_,BB_GAIN_TABLE,B2,FREQ_DETECT,HYBRII_B_AFE,_BC_SECURE_TEST_,FREQ_DETECT,BCN_ERR,NO_HOST,MCCO,KEEP_ALIVE,UART_RAW,UART_HOST_INTF,UART_GPIO_INTERRUPT,MCCO,SW_RECOVERY,HYBRII_802154,DEBUG_DATAPATH,HPGP_DRIVER_APP,LRWPAN_DRIVER_APP,NWKSTARTUP_APP,ROUTE_APP,RTOPO_APP,REGISTER_APP,LLP_APP,BRIDGE,DEVICEINTF_APP,SMARTLIGHT_APP,LED_SMART_LIGHT,HQ_LINK_TEST,ROUTE_RECOVERY
  c misc: NOAREGS
  c include: ..\..\..\..\firmware\common\datapath;..\..\..\..\firmware\common\include;..\..\..\..\firmware\hal;..\..\..\..\firmware\hpgp\src\crypto;..\..\..\..\firmware\hpgp\src\ctrl;..\..\..\..\firmware\hpgp\src\hal;..\..\..\..\firmware\hpgp\src\link;..\..\..\..\firmware\hpgp\src\mux;..\..\..\..\firmware\hpgp\src\nma;..\..\..\..\firmware\hpgp\src\route;..\..\..\..\firmware\hpgp\src\test;..\..\..\..\firmware\project\hal\src;..\..\..\..\firmware\zigbee;..\..\..\..\components\aps\inc;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\firmware\common;..\..\..\..\firmware\hpgp;..\..\..\..\firmware\hpgp\src;..\..\..\..\firmware\app_support;..\..\..\..\firmware\HybriiB_configuration_rw\src;..\..\..\..\components\drivers\gpio\inc;..\..\..\..\components\drivers\hpgp\inc;..\..\..\..\components\drivers\nwk\inc;..\..\..\..\components\drivers\ieee802154\inc;..\..\..\..\components;..\..\..\..\components\osal\inc;..\..\..\..\components\nma\hpgp\inc;..\..\..\..\components\nma\ieee802154\inc;..\..\..\..\components\nma;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\components\drivers\flash\inc;..\..\..\..\components\ieee802154\inc;..\..\..\..\components\drivers\uart\inc;..\..\..\..\components\utilities;..\..\..\..\components\drivers\hpgp\inc;..\..\..\..\components\drivers\ieee802154\inc;..\..\..\..\components\drivers\nwk\inc;..\..\..\..\components\utilities\debug\inc;..\..\..\..\sampleapp\inc;..\..\..\..\sampleapp\src;..\..\inc;..\..\..\..\components\drivers\i2c\inc;..\..\..\..\components\drivers\gvspi\inc
  link misc: REMOVEUNUSED
  group startup
    ../../../../firmware/project/hal/src/: clear_char.A51
    ../../../../OS/: CONF_TNY_wo_timer_int.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../../../firmware/hpgp/src/: green.c
    ../../../../firmware/common/: interrupt.c
    ../../../../firmware/hal/: gv701x_uartdriver.c
  group Bank 0
    ../../../../firmware/common/: utils.c stm.c list.c uart.c dmm.c event.c
    ../../../../firmware/hal/: hal_common.c
    ../../../../firmware/hpgp/src/: hpgpctrl.c
    ../../../../firmware/hpgp/src/crypto/: aes.c
    ../../../../firmware/hpgp/src/link/: akm.c hom.c
    ../../../../components/utilities/debug/src/: fm.c
    ../../../../sampleapp/src/: smartlightapp.c
    ../../../../components/drivers/i2c/src/: gv701x_i2c.c
  group Bank 1
    ../../../../firmware/hpgp/src/link/: crm.c
    ../../../../firmware/common/: gv701x_flash.c gv701x_cfg.c ui_utils.c sys_common.c
    ../../../../firmware/project/hal/src/: hal_hpgp_reset.c hhal_led.c
    ../../../../firmware/hpgp/src/hal/: hal.c
    ../../../../firmware/HybriiB_configuration_rw/src/: sys_config_data_utils.c
    ../../../../firmware/hpgp/src/mux/: muxl.c
    ../../../../firmware/hpgp/src/crypto/: crc32.c
    ../../../../firmware/hal/: hal_eth.c hal_hpgp.c hal_spi.c
    ../../../../firmware/hpgp/src/route/: hpgp_route.c
  group Bank 2
    ../../../../components/drivers/nwk/src/: gv701x_nwkstartup.c
    ../../../sampleapp/src/: register.c llpapp.c
    ../../../../sampleapp/src/: deviceintfapp.c
    ../../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
    ../../../../firmware/hpgp/src/link/: nam.c psm.c
    ../../../../firmware/hal/: hal_hpgpTx.c
    ../../../../components/drivers/gvspi/src/: gv701x_gvspi.c
  group Bank 3
    ../../../../firmware/hpgp/src/link/: nsm_sta.c linkl.c
    ../../../../firmware/hal/: hal_hpgpRx.c
    ../../../../firmware/common/: ism.c
  group Bank 4
    ../../../../firmware/hpgp/src/link/: nsm_cco.c
    ../../../../firmware/hpgp/src/test/: htm.c
    ../../../../firmware/hpgp/src/ctrl/: ctrll.c
  group Bank 5
    ../../../../firmware/zigbee/: mac_diag.c mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c mac_mcps_data.c mac_pib.c mac_security.c
    ../../../../firmware/common/datapath/: FrameTask.c
    ../../../../firmware/app_support/: app_sup_layer.c
  group Bank 6
    ../../../../firmware/zigbee/: qmm.c bmm.c mac_start.c mac_scan.c mac_orphan.c mac_associate.c mac_beacon.c mac_disassociate.c mac_host_cb.c mac_misc.c mac_poll.c mac_rx_enable.c mac_sync.c
    ../../../../components/osal/src/: gv701x_osal.c
    ../../../../firmware/hpgp/src/nma/: nma.c
    ../../../../firmware/common/datapath/: datapath.c
  group Bank 7
    ../../src/: route_topo.c
    ../../../sampleapp/src/: route.c
    ../../../../components/drivers/hpgp/src/: gv701x_hpgpdriver.c
    ../../../../components/drivers/ieee802154/src/: gv701x_lrwpandriver.c
