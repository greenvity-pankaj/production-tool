# Keil uVision project uartapp.uvproj, settings and files
target UartApp (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: uartapp +hex
  c flags: Optimize=9
  c define: inline,P8051,C51
  c misc: NOAREGS
  c include: ..\..\components\aps\inc;..\..\components\utilities\datatype\inc;..\..\components\utilities\event\inc;..\..\components\utilities\linklist\inc;..\..\components\utilities\timer\inc;..\src;..\inc;..\..\components\hpgp\inc;..\..\OS
  link misc: REMOVEUNUSED
  group startup
    ../../OS/: CONF_TNY.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../firmware-lib/: common.LIB
  group Bank 0
    ../../firmware-lib/: bank0.LIB
  group Bank 1
    ../../firmware-lib/: bank1.LIB
  group Bank 2
    ../../firmware-lib/: bank2.LIB
  group Bank 3
    ../../firmware-lib/: bank3.LIB
  group Bank 4
    ../../firmware-lib/: bank4.LIB
  group Bank 5
    ../../firmware-lib/: bank5.LIB
  group Bank 6
    ../../firmware-lib/: bank6.LIB
  group Bank 7
    ../src/: gv701x_driver.c gv701x_task.c uartapp.c
