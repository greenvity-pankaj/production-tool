# Keil uVision project fwLIB1.uvproj, settings and files
target fwLIB1 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: fwLIB1 +hex (library)
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,HPGP_DEBUG,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HPGP_MAC_SAP,NMA,NEW_SYNC,UM,HYBRII_B,Hybrii_B,HW_SPI_TX_CRC,HW_SPI_RX_CRC,B_ASICPLC,HYBRII_ASIC_A2,BB_CAL,_CRC_VERIFY_,BB_GAIN_TABLE,B2,FREQ_DETECT,HYBRII_B_AFE,_BC_SECURE_TEST_,FREQ_DETECT,BCN_ERR,NO_HOST,MCCO,KEEP_ALIVE,UART_RAW,UART_HOST_INTF,UART_GPIO_INTERRUPT,MCCO,SW_RECOVERY,HYBRII_802154,DEBUG_DATAPATH
  c misc: NOAREGS
  c include: ..\..\..\..\firmware\common\datapath;..\..\..\..\firmware\common\include;..\..\..\..\firmware\hal;..\..\..\..\firmware\hpgp\src\crypto;..\..\..\..\firmware\hpgp\src\ctrl;..\..\..\..\firmware\hpgp\src\hal;..\..\..\..\firmware\hpgp\src\link;..\..\..\..\firmware\hpgp\src\mux;..\..\..\..\firmware\hpgp\src\nma;..\..\..\..\firmware\hpgp\src\route;..\..\..\..\firmware\hpgp\src\test;..\..\..\..\firmware\project\hal\src;..\..\..\..\firmware\zigbee;..\..\..\..\components\aps\inc;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\firmware\common;..\..\..\..\firmware\hpgp;..\..\..\..\firmware\hpgp\src;..\..\..\..\firmware\app_support;..\..\..\..\firmware\HybriiB_configuration_rw\src;..\..\..\..\components\drivers\gpio\inc;..\..\..\..\components;..\..\..\..\components\osal\inc;..\..\..\..\components\nma\hpgp\inc;..\..\..\..\components\nma\ieee802154\inc;..\..\..\..\components\nma;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\components\drivers\flash\inc;..\..\..\..\components\ieee802154\inc;..\..\..\..\components\drivers\uart\inc;..\..\..\..\components\utilities;..\..\..\..\components\utilities\debug\inc;..\..\..\..\components\drivers\i2c\inc,..\..\..\..\components\drivers\gvspi\inc
  link misc: REMOVEUNUSED
  group startup
    ../../../../firmware/project/hal/src/: clear_char.A51
    ../../../../OS/: CONF_TNY_wo_timer_int.A51 L51_PALM_BANK.A51 STARTUP.A51
  group Bank 1
    ../../../../firmware/hpgp/src/link/: crm.c
    ../../../../firmware/common/: gv701x_flash.c gv701x_cfg.c ui_utils.c sys_common.c
    ../../../../firmware/project/hal/src/: hal_hpgp_reset.c hhal_led.c
    ../../../../firmware/hpgp/src/hal/: hal.c
    ../../../../firmware/HybriiB_configuration_rw/src/: sys_config_data_utils.c
    ../../../../firmware/hpgp/src/mux/: muxl.c
    ../../../../firmware/hpgp/src/crypto/: crc32.c
    ../../../../firmware/hal/: hal_eth.c hal_hpgp.c hal_spi.c
    ../../../../firmware/hpgp/src/route/: hpgp_route.c
