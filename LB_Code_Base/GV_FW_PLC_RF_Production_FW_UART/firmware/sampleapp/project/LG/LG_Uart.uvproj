# Keil uVision project LG_Uart.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: uartapp +hex
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HPGP_DEBUG,HYBRII_ETH_, HPGP_MAC_SAP,NMA, HYBRII_SPI_,NEW_SYNC,UM,HYBRII_B,Hybrii_B, HW_SPI_TX_CRC_,HW_SPI_RX_CRC_,AUTH_AES,B_ASICPLC,FREQ_DETECT,DEBUG_DATAPATH_,PLC_TEST,SW_RECOVERY,DEBUG_DATAPATH_,NO_HOST,UART_RAW,UART_HOST_INTF,LG_UART_CONFIG,LG_WAR,BCN_ERR,LOG_FLASH_,HPGP_DRIVER_APP,NWKSTARTUP_APP,UART_APP,KEEP_ALIVE,UART_LOOPBACK,SW_BCST
  c misc: NOAREGS
  c include: ..\..\..\firmware\common\datapath;..\..\..\firmware\common\include;..\..\..\firmware\hal;..\..\..\firmware\hpgp\src\crypto;..\..\..\firmware\hpgp\src\ctrl;..\..\..\firmware\hpgp\src\hal;..\..\..\firmware\hpgp\src\link;..\..\..\firmware\hpgp\src\mux;..\..\..\firmware\hpgp\src\nma;..\..\..\firmware\hpgp\src\route;..\..\..\firmware\hpgp\src\sap;..\..\..\firmware\hpgp\src\test;..\..\..\firmware\project\hal\src;..\..\..\firmware\zigbee;..\..\..\components\aps\inc;..\..\..\components\utilities\datatype\inc;..\..\..\components\utilities\event\inc;..\..\..\components\utilities\linklist\inc;..\..\..\components\utilities\timer\inc;..\..\..\components\hpgp\inc;..\..\..\firmware\common;..\..\..\firmware\hpgp;..\..\..\firmware\hpgp\src;..\..\..\firmware\app_support;..\..\..\firmware\HybriiB_configuration_rw\src;..\..\..\components\drivers\gpio\inc;..\..\..\components\drivers\hpgp\inc;..\..\..\components\drivers\nwk\inc;..\..\..\components\drivers\ieee802154\inc;..\..\..\components;..\..\..\components\osal\inc;..\..\..\components\nma\hpgp\inc;..\..\..\components\nma\ieee802154\inc;..\..\..\components\nma;..\..\..\components\utilities\event\inc;..\..\..\components\hpgp\inc;..\..\..\components\drivers\flash\inc;..\..\..\components\ieee802154\inc;..\..\..\components\drivers\uart\inc;..\..\..\components\utilities;..\..\..\sampleapp\src;..\..\..\sampleapp\inc
  link misc: REMOVEUNUSED
  group startup
    ../../../OS/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY_wo_timer_int.A51
    ../../../firmware/project/hal/src/: clear_char.A51
  group common
    ../../../firmware/hpgp/src/: green.c
    ../../../firmware/common/: interrupt.c
    ../../../firmware/hal/: gv701x_uartdriver.c
  group Bank 0
    ../../../firmware/common/: stm.c list.c fm.c uart.c dmm.c event.c
    ../../../firmware/hal/: hal_common.c
    ../../../firmware/hpgp/src/: hpgpctrl.c
    ../../../firmware/hpgp/src/crypto/: aes.c
    ../../../firmware/hpgp/src/link/: akm.c hom.c
  group Bank 1
    ../../../firmware/HybriiB_configuration_rw/src/: sys_config_data_utils.c
    ../../../firmware/hpgp/src/hal/: hal.c
    ../../../firmware/common/: ui_utils.c sys_common.c
    ../../../firmware/hpgp/src/mux/: muxl.c
    ../../../firmware/hpgp/src/crypto/: crc32.c
    ../../../firmware/project/hal/src/: hhal_led.c
    ../../../firmware/hal/: hal_hpgp.c hal_spi.c
    ../../../firmware/hpgp/src/route/: hpgp_route.c
  group Bank 2
    ../../../firmware/hal/: hal_eth.c hal_hpgpTx.c
    ../../../firmware/hpgp/src/link/: nam.c
  group Bank 3
    ../../../firmware/hal/: hal_hpgpRx.c
    ../../../firmware/common/: utils.c ism.c
    ../../../firmware/hpgp/src/link/: crm.c linkl.c nsm_cco.c
  group Bank 4
    ../../../firmware/hpgp/src/test/: htm.c
    ../../../firmware/hpgp/src/ctrl/: ctrll.c
    ../../../firmware/hpgp/src/link/: nsm_sta.c
  group Bank 5
    ../../../firmware/common/datapath/: datapath.c FrameTask.c
    ../../../firmware/project/hal/src/: hal_hpgp_reset.c
    ../../../firmware/app_support/: app_sup_layer.c
  group Bank 6
    ../../../firmware/hpgp/src/link/: psm.c
    ../../../firmware/hpgp/src/nma/: nma.c
    ../../../firmware/common/: gv701x_cfg.c gv701x_flash.c
    ../../../components/osal/src/: gv701x_osal.c
    ../../../components/drivers/nwk/src/: gv701x_nwkstartup.c
    ../../../components/drivers/hpgp/src/: gv701x_hpgpdriver.c
    ../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
  group Bank 7
    ../../../sampleapp/src/: uartapp_new.c
