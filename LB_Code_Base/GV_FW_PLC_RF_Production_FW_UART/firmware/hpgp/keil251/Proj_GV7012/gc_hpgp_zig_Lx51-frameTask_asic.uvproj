# Keil uVision project gc_hpgp_zig_Lx51-frameTask_asic.uvproj, settings and files
target GV7011 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=9
  c define: inline,P8051,HPGP_HAL,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST, RTX51_TINY_OS, HYBRII_ASIC, PLC_SW_SYNC,HPGP_MAC_SAP,NMA, AUTH_AES, HYBRII_SPI,NEW_SYNC,UM,HYBRII_B,HYBRII_802154,HYBRII_ASIC_A2,Hybrii_B,HYBRII_B_AFE,BB_CAL,BB_GAIN_TABLE,UART_RAW,B_ASICPLC,FREQ_DETECT,BCN_ERR,KEEP_ALIVE,MCCO
  c misc: NOAREGS
  c include: ..\..\..\common\datapath;..\..\..\common\include;..\..\..\hal;..\..\src\crypto;..\..\src\ctrl;..\..\src\hal;..\..\src\link;..\..\src\mux;..\..\src\nma;..\..\src\route;..\..\src\test;..\..\..\project\hal\src;..\..\..\zigbee;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\common;..\..\..\hpgp;..\..\src;..\..\..\HybriiB_configuration_rw\src;..\..\..\..\components\drivers\flash\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\components\nma\hpgp\inc;..\..\..\..\components\osal\inc;..\..\..\..\components\drivers\gpio\inc;..\..\..\..\components\nma;..\..\..\..\components\nma\ieee802154\inc;..\..\..\..\components\ieee802154\inc;..\..\..\..\components\utilities;..\..\..\..\components\drivers\uart\inc;..\..\..\..\components\utilities\debug\inc;..\..\..\..\components\utilities\debug\inc
  link misc: REMOVEUNUSED
  group startup
    ../../../project/hal/src/: clear_char.A51
    ../../../../OS/: CONF_TNY.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../../common/: interrupt.c
    ../../src/: green.c
    ../../../hal/: gv701x_uartdriver.c
  group Bank 0
    ../../../common/: sys_common.c uart.c dmm.c
    ../../../project/hal/src/: hhal_led.c
    ../../../hal/: hal_hpgpTx.c hal_spi.c hal_hpgp.c hal_eth.c hal_hpgpRx.c
    ../../src/: hpgpctrl.c
    ../../../../components/utilities/debug/src/: fm.c
  group Bank 1
    ../../../common/: utils.c stm.c
    ../../../hal/: hal_common.c
    ../../src/link/: crm.c hom.c akm.c
    ../../src/crypto/: aes.c crc32.c
    ../../src/hal/: hal.c
    ../../src/route/: hpgp_route.c
  group Bank 2
    ../../../common/: list.c ui_utils.c
    ../../src/test/: htm.c
    ../../src/link/: linkl.c
    ../../../common/datapath/: datapath.c FrameTask.c
    ../../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
  group Bank 3
    ../../../common/: ism.c
    ../../src/link/: nam.c nsm_cco.c
  group Bank 4
    ../../../common/: event.c
    ../../src/ctrl/: ctrll.c
    ../../src/link/: nsm_sta.c
    ../../src/nma/: nma.c
    ../../src/mux/: muxl.c
  group Bank 5
    ../../../zigbee/: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c mac_mcps_data.c mac_pib.c mac_security.c
  group Bank 6
    ../../../zigbee/: mac_beacon.c mac_associate.c mac_disassociate.c mac_host_cb.c mac_misc.c mac_poll.c mac_rx_enable.c mac_sync.c
  group Bank 7
    ../../../common/: gv701x_cfg.c gv701x_flash.c
    ../../../zigbee/: bmm.c qmm.c mac_orphan.c mac_scan.c mac_start.c mac_diag.c
    ../../../project/hal/src/: hal_hpgp_reset.c
    ../../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
