# Keil uVision project gc_hpgp.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: gc_hpgp +hex
  c flags: Optimize=8
  c define: P8051, HYBRII_8051, HYBRII_HPGP, HYBRII_ASIC, PLC_SW_SYNC=1, inline, HPGP_HAL_TEST,RTX51_TINY_OS,_TIMER_INTERRUPT_,SNIFFER,Hybrii_B, NEW_SYNC,_TIMER_INTERRUPT_,HYBRII_B,GPIO_FPGA,HW_SPI_TX_CRC,HW_SPI_RX_CRC,_CRC_VERIFY_, HYBRII_SPI,SNIFFER,HYBRII_ETH,DEBUG_DATAPATH
  c include: ..\..\common;..\..\project\hal\src;..\..\hpgp\src\mux;..\..\hpgp\src\link;..\..\hpgp\src\ctrl;..\..\hpgp\src\nma;..\..\hal;.\src;..\..\hpgp\src\hal;..\..\hpgp\src\sap;..\..\hpgp\src\test;..\..\hpgp\src\;..\..\datapath;..\..\hpgp\src\route
  group startup
    ../../common/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY.A51
    ./src/: clear_char.A51
  group common
    ../../hal/: hal_common.c
    ../../common/: list.c utils.c
  group Bank 0
    ../../common/: fm.c
    ./src/: hal_main.C hhal_tst.c
  group Bank 1
    ./src/: ehal_tst.c chal_tst.c
    ../../hal/: hal_hpgpTx.c hal_hpgpRx.c
  group Bank 2
    ../../hal/: hal_eth.c hal_hpgp.c
    ../../common/: sys_common.c
  group Bank 3
    ./src/: hhal_led.c
    ../../hal/: hal_spi.c
  group Bank 4
    ./src/: ihal_tst.c ihal_ui.c
    ../../datapath/: datapath.c FrameTask.c
