# Keil uVision project LG_Uart_old.uvproj, settings and files
target Green_8x251 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: uartapp +hex
  c flags: Optimize=9
  c define: inline,P8051,C51,HPGP_HAL,HYBRII_8051,HYBRII_HPGP,CCO_FUNC,STA_FUNC,HPGP_TEST,RTX51_TINY_OS,HYBRII_ASIC,PLC_SW_SYNC,HPGP_DEBUG,HYBRII_ETH_, HPGP_MAC_SAP,NMA, HYBRII_SPI_,NEW_SYNC,UM,HYBRII_B,Hybrii_B, HW_SPI_TX_CRC_,HW_SPI_RX_CRC_,AUTH_AES,B_ASICPLC,FREQ_DETECT,DEBUG_DATAPATH_,PLC_TEST,SW_RECOVERY,DEBUG_DATAPATH_,NO_HOST,UART_RAW,UART_HOST_INTF,LG_UART_CONFIG,LG_WAR,BCN_ERR,UART_OLD_APP,SW_BCST,KEEP_ALIVE,SW_RECOVERY,UART_LOOPBACK
  c misc: NOAREGS
  c include: ..\..\..\firmware\common\datapath;..\..\..\firmware\common\include;..\..\..\firmware\hal;..\..\..\firmware\hpgp\src\crypto;..\..\..\firmware\hpgp\src\ctrl;..\..\..\firmware\hpgp\src\hal;..\..\..\firmware\hpgp\src\link;..\..\..\firmware\hpgp\src\mux;..\..\..\firmware\hpgp\src\nma;..\..\..\firmware\hpgp\src\route;..\..\..\firmware\hpgp\src\sap;..\..\..\firmware\hpgp\src\test;..\..\..\firmware\project\hal\src;..\..\..\firmware\zigbee;..\..\..\components\utilities\datatype\inc;..\..\..\components\utilities\event\inc;..\..\..\components\utilities\linklist\inc;..\..\..\components\utilities\timer\inc;..\..\..\components\hpgp\inc;..\..\..\firmware\common;..\..\..\firmware\hpgp;..\..\..\firmware\hpgp\src;..\..\..\firmware\app_support;..\..\..\firmware\HybriiB_configuration_rw\src;..\..\..\components\drivers\gpio\inc;..\..\..\components;..\..\..\components\osal\inc;..\..\..\components\nma\hpgp\inc;..\..\..\components\nma;..\..\..\components\utilities\event\inc;..\..\..\components\hpgp\inc;..\..\..\components\drivers\flash\inc;..\..\..\components\drivers\uart\inc;..\..\..\components\utilities;..\..\..\sampleapp\src;..\..\..\sampleapp\inc
  link misc: REMOVEUNUSED
  group startup
    ../../../OS/: STARTUP.A51 L51_PALM_BANK.A51 CONF_TNY_wo_timer_int.A51
    ../../../firmware/project/hal/src/: clear_char.A51
  group common
    ../../../firmware/hpgp/src/: green.c
    ../../../firmware/hal/: gv701x_uartdriver.c
    ../../../firmware/common/: interrupt.c
  group Bank 0
    ../../../firmware/hal/: hal_common.c
    ../../../firmware/common/: list.c fm.c uart.c dmm.c event.c
    ../../hal/: hal_hpgpRx.c
    ../../../firmware/hpgp/src/: hpgpctrl.c
  group Bank 1
    ../../common/: stm.c
    ../../../firmware/project/hal/src/: hhal_led.c
    ../../hal/: hal_eth.c
    ../../../firmware/hal/: hal_hpgp.c hal_spi.c
    ../../../firmware/common/: sys_common.c
    ../../../firmware/hpgp/src/route/: hpgp_route.c
  group Bank 2
    ../../../firmware/hal/: hal_hpgpTx.c
    ../../common/datapath/: datapath.c FrameTask.c
  group Bank 3
    ../../../firmware/common/: ism.c
    ../../../firmware/hpgp/src/link/: crm.c linkl.c nsm_cco.c
  group Bank 4
    ../../../firmware/hpgp/src/ctrl/: ctrll.c
    ../../../firmware/hpgp/src/link/: nsm_sta.c
    ../../hpgp/src/nma/: nma.c
    ../../hpgp/src/mux/: muxl.c
  group Bank 5
    ../../hpgp/src/link/: nam.c
    ../../hpgp/src/test/: htm.c
    ../../hpgp/src/hal/: hal.c
    ../../common/: ui_utils.c
    ../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
  group Bank 6
    ../../common/: utils.c gv701x_flash.c
    ../../hpgp/src/crypto/: aes.c crc32.c
    ../../hpgp/src/link/: hom.c akm.c psm.c
    ../../project/hal/src/: hal_hpgp_reset.c
    ../../app_support/: app_sup_layer.c
    ../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
  group Bank 7
    ../../../sampleapp/src/: uartapp.c gv701x_driver.c gv701x_task.c
