# Keil uVision project CodeBankTestAsic-ZP-Bridge-A2 - SysConfig.uvproj, settings and files
target Target 1 (MCS-51)
  device: Palm8051 PalmChip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ZP Bridge B2 Fcfg +hex
  c flags: Optimize=9
  c define: P8051  HYBRII_802154, HYBRII_ASIC, HYBRII_SPI, HPGP_HAL_TEST, RTX51_TINY_OS, SPI_DIAG, HYBRII_ASIC_A2, HYBRII_HPGP, HYBRII_ETH, PLC_SW_SYNC, inline, BB_GAIN_TABLE,  BB_CAL, HYBRII_B, HYBRII_B_AFE, B_ASICPLC, FT, Z_P_BRIDGE, Flash_Config, MPER, ZBMAC_DIAG, MAC_802154_TASK, HAL_802154_TASK
  c include: ..\..\..\zigbee;..\..\..\common;..\..\..\hal;..\..\..\hpgp\src;..\..\..\project\hal\src;..\..\..\hpgp\src\hal;..\..\..\hpgp\src\nma;..\..\..\common\datapath;..\..\..\hpgp\src\link;..\..\..\..\components\utilities\datatype\inc;..\..\..\..\components\utilities\event\inc;..\..\..\..\components\utilities\linklist\inc;..\..\..\..\components\utilities\timer\inc;..\..\..\..\components\drivers\gpio\inc;..\..\..\..\components\osal\inc;..\..\..\HybriiB_configuration_rw\src;..\..\..\..\components\ieee802154\inc;..\..\..\..\components\hpgp\inc;..\..\..\..\components\nma\hpgp\inc;..\..\..\..\components\nma\ieee802154\inc;..\..\..\..\components\nma;..\..\..\..\components\drivers\flash\inc;..\..\..\..\components\utilities;..\..\..\..\components\utilities\debug\inc
  group startup
    ../../../../OS/: CONF_TNY.A51 L51_PALM_BANK.A51 STARTUP.A51
  group common
    ../../../common/: stm.c list.c ism.c sys_common.c interrupt.c
  group bank 0
    ../../: mac.c mac_api.c mac_data.c mac_hal.c mac_hal_intf.c mac_hal_pib.c
  group bank 1
    ../../: mac_mcps_data.c mac_associate.c mac_beacon.c mac_security.c mac_orphan.c mac_start.c mac_pib.c mac_scan.c mac_disassociate.c
  group bank 2
    ../../../common/: utils.c gv701x_cfg.c
    ../../: qmm.c bmm.c mac_poll.c mac_sync.c mac_misc.c mac_rx_enable.c
    ../../../hal/: hal_common.c hal_spi.c
  group bank 3
    ../../: mac_host_cb.c main.c mac_diag.c
    ../../../HybriiB_configuration_rw/src/: sys_config_data_utils.c
  group bank 4
    ../../../project/hal/src/: chal_tst.c ehal_tst.c
    ../../../common/: ui_utils.c
    ../../../hal/: hal_hpgpTx.c hal_hpgpRx.c
  group bank 5
    ../../../common/: uart.c
    ../../../hal/: hal_eth.c hal_hpgp.c
    ../../../../components/utilities/debug/src/: fm.c
  group bank 6
    ../../../project/hal/src/: hhal_tst.c
    ../../../common/datapath/: datapath.c FrameTask.c
    ../../../../components/drivers/gpio/src/: gv701x_gpiodriver.c
